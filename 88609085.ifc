Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-04-26T18:52:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Apr 26 18:52:09 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8a4ff089-cb36-42f2-8fd8-901cdd0d1ac6\a0b2eb95-0b8d-44fd-b22c-1a8b637a58d7\ifc * Database version: 5507 * Database creation date: Fri Apr 26 18:52:08 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Apr 26 18:52:09 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Apr 26 18:52:09 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 88609085 Cover part for shower faucet, 88609085:88609085 Cover part for shower faucet:15238
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 66.637 mm; NominalHeight: 169.981 mm; NominalWidth: 170 mm
Type - General - Author: BIMStone; BIMObjectName: 88609085; ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 20/04/2024
Type - Green Building Properties - Approval ABP: PA-IX 38190/I; Approval DVGW: DW-6509CS0197; EAN Number: 4057304012556; EN Standard: EN 1111; ETIM Class Number: EC010546 Mechanical control system for shower; Noise Class: I (ISO 3822); Sales Package dimensions (LxWxH): 204 x 186 x 174; UNSPSC Class Number: 30181810 Faucet trim; URL ABP: http://static.hansa.com/ABP/88609085; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/88609085; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL DVGW: http://static.hansa.com/DVGW/88609085; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/88609085; 3D View: https://static.hansa.com/AR/88609085; Catalog Drawing URL: http://static.hansa.com/catdrw/88609085; Dimension Drawing URL: http://static.hansa.com/dimdrw/88609085; FDV Document URL: http://www.hansa.com/datasheet/88609085/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/88609085; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/88609085; Interactive AR View URL: https://static.hansa.com/AR/88609085; Manufacturer: HANSA; Market: International;Germany;Austria;Switzerland;Belgium;Netherlands;France;Czech Republic;Slovakia;Hungary;Romania;Italy;Spain;Greece;Portugal;Australia; Mobile Product Information URL: http://mpi.hansa.com/88609085; Model: 88609085 Cover part for shower faucet; Name_en: 88609085 Cover part for shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 88609085; Product Family: HANSACLINICA Safety+; Product Image URL: http://static.hansa.com/image/88609085; Product URL: http://static.hansa.com/88609085; Spare-Part Information URL: http://static.hansa.com/sp/88609085; Technical DataSheet URL: http://www.hansa.com/datasheet/88609085/en; Type Name: 88609085 Cover part for shower faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Additional Features: protected against back-flow in domestic use (according to DIN EN 1717) Safety lock against scalding 38°C (36°-44°); Advanced Features: Thermal disinfection without cartridge readjustment; Backflow Prevention EN1717: EB; Concealed Parts: Round rosette;Function unit;BLUECLICK for an easy, screwless trim plate installation;BLUETUNE alignment after installation of +/- 3,5º; DN Size: 170 mm; Excluded Items: Without flow control;Without diverter; Flow Rate At 300kPa: 0.0141259 m3/s; Installation Type: Concealed wall mounting; Lever Handle: Temperature control handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Thermostatic cartridge for automatic temperature control;Non-return valve(s); Surface treatment: Chrome; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 88609085; Features: Trim Kit;Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 88609085; Name: 88609085 Cover part for shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 170x70x170 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0515387 m2; Volume: 0.00192495 m3
Identity Data - Mark: 6
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 88609085: 88609085 Cover part for shower faucet; Family and Type: 88609085: 88609085 Cover part for shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 88609085: 88609085 Cover part for shower faucet; Type Id: 88609085: 88609085 Cover part for shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
